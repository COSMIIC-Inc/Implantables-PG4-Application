# IAR project rmStim.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x260
  General.SCRStackSize: 24
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: can128 AT90CAN128
  ICCAVR.CCDefines: __AT90CAN128__; ENABLE_BIT_DEFINITIONS
  ICCAVR.newCCIncludePaths: ; ..\canFest\app; ..\canFest\include; ..\canFest\include\avr
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgcan128.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group app
    ./: acceltemp.c app.c eedata.c pulseGen.c runcanserver.c scheduler.c stimTask.c
  group canFest
    ../canFest/source/avr/: can_AVR.c timer_AVR.c
    ../canFest/source/: emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
    ../canFest/app/: ObjDict.c
